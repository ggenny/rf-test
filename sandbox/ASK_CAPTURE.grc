options:
  parameters:
    generate_options: qt_gui
    id: ASK_CAPTURE
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cut
  id: variable_qtgui_range
  parameters:
    start: '1000'
    step: '1000'
    stop: '100000'
    value: '32000'
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    start: 10e6
    step: 0.1e6
    stop: 1000e6
    value: 433.90e6
  states: {}
- name: gain
  id: variable_qtgui_range
  parameters:
    start: '0'
    step: '1'
    stop: '100'
    value: '20'
  states: {}
- name: samp_per_sym
  id: variable_qtgui_range
  parameters:
    start: '1'
    step: '1'
    stop: '10000'
    value: '320'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: gain
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_float_to_uchar_1
  id: blocks_float_to_uchar
  parameters:
    bias: '0'
    scale: '1'
    vlen: '1'
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: blocks_threshold_ff_0
  id: blocks_threshold_ff
  parameters:
    high: '1.0'
    init: '0'
    low: '0.5'
  states: {}
- name: digital_clock_recovery_mm_xx_0
  id: digital_clock_recovery_mm_xx
  parameters:
    gain_mu: '0.175'
    gain_omega: 0.25*0.175*0.175
    mu: '0.5'
    omega: samp_per_sym*(1+0.0)
    omega_relative_limit: '0.005'
    type: float
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nEmbedded Python Blocks:\n\nEach time this file is saved, GRC will instantiate the first class it finds\nto get ports and parameters of your block. The arguments to __init__  will\nbe the parameters. All of them are required to have default values!\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport sys\n\nclass blk(gr.sync_block):\n    def __init__(self, null_limit=10):\n        gr.sync_block.__init__(self,\n            name='Data Stream Printer',\n            in_sig=[np.uint8],  # Assume the input signal is bytes\n            out_sig=None)  # This block does not produce output\n\n        self.null_limit = null_limit\n        self.printing = False\n        self.null_count = 0\n\n    def work(self, input_items, output_items):\n        in_data = input_items[0]\n        for byte in in_data:\n            if byte != 0:\n                if not self.printing:\n                    self.printing = True  # Start printing when the first non-null byte is encountered\n                self.null_count = 0  # Reset null count when a non-null byte is received\n            else:\n                self.null_count += 1  # Increment null count\n\n            if self.printing:\n                print(self.print_bits(byte), end='')\n                sys.stdout.flush()  # Esegue un flush del buffer di stdout per mostrare l'output immediatamente\n        \n            if self.null_count >= self.null_limit:\n                self.printing = False  # Stop printing after the limit of null bytes\n\n        return len(in_data)\n\n    def print_bits(self, byte):\n        return ''.join(f'{b:08b}' for b in [byte])\n\n"
    null_limit: '50'
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: cut
    decim: '1'
    gain: '5'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '100000'
    win: window.WIN_HAMMING
  states: {}
- name: network_udp_sink_0
  id: network_udp_sink
  parameters:
    addr: 127.0.0.1
    header: '0'
    payloadsize: '1472'
    port: '2000'
    send_eof: 'False'
    type: byte
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '2'
    grid: 'True'
    ncols: '200'
    nrows: '100'
    samp_rate: samp_rate
    type: byte
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '100000'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: '100000'
    srate: samp_rate
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: freq
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_agc_xx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_threshold_ff_0, '0']
- [blocks_complex_to_mag_squared_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_float_to_uchar_1, '0', blocks_pack_k_bits_bb_0, '0']
- [blocks_float_to_uchar_1, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_pack_k_bits_bb_0, '0', epy_block_0, '0']
- [blocks_pack_k_bits_bb_0, '0', network_udp_sink_0, '0']
- [blocks_threshold_ff_0, '0', digital_clock_recovery_mm_xx_0, '0']
- [blocks_threshold_ff_0, '0', qtgui_time_sink_x_1, '0']
- [digital_clock_recovery_mm_xx_0, '0', blocks_float_to_uchar_1, '0']
- [low_pass_filter_0, '0', analog_agc_xx_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-678-g2ccb54a3
