options:
  parameters:
    author: mettus
    category: Custom
    generate_options: qt_gui
    id: demo_gmsk
    output_language: python
  states: {}

blocks:
- name: beta
  id: variable_qtgui_range
  parameters:
    gui_hint: 3,0,1,1
    label: k3 (IP3)
    start: '-.1'
    step: '0.001'
    stop: '0'
    value: '0'
  states: {}
- name: const_size
  id: variable
  parameters:
    value: '4'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Frequency Offset
    start: '-0.5'
    step: '0.001'
    stop: '0.5'
    value: '0'
  states: {}
- name: i_ofs
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,1
    label: I offset
    start: '-1'
    step: '0.001'
    stop: '1'
    value: '0'
  states: {}
- name: magbal
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,1
    label: IQ Magnitude Imbalance
    start: '0'
    step: '0.1'
    stop: '10'
    value: '0'
  states: {}
- name: phase_noise_mag
  id: variable_qtgui_range
  parameters:
    gui_hint: 0, 0, 1,1
    label: Phase Noise Mag (dB)
    start: '-100'
    step: '1'
    stop: '0'
    value: '-100'
  states: {}
- name: phasebal
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,1,1,1
    label: IQ Phase Imbalance
    start: '0'
    step: '0.1'
    stop: '45'
    value: '0'
  states: {}
- name: q_ofs
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,1,1,1
    label: Q offset
    start: '-1'
    step: '0.001'
    stop: '1'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.0'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/ggenny/Develop/rf-test/test_file_IQ
    type: complex
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ggenny/Develop/rf-test/test_file
    repeat: 'True'
    type: byte
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '10'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.3'
    log: 'True'
    samples_per_symbol: '10'
    verbose: 'True'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    mode: '2'
    port: '4000'
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 4,0,1,1
    name: ''
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,1,1,1
    marker1: '1'
    name: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_file_source_0, '0', digital_gmsk_mod_0, '0']
- [digital_gmsk_demod_0, '0', network_tcp_sink_0, '0']
- [digital_gmsk_mod_0, '0', analog_quadrature_demod_cf_0, '0']
- [digital_gmsk_mod_0, '0', blocks_file_sink_0, '0']
- [digital_gmsk_mod_0, '0', digital_gmsk_demod_0, '0']
- [digital_gmsk_mod_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-678-g2ccb54a3
