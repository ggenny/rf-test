options:
  parameters:
    generate_options: qt_gui
    id: demo_demod_gmsk
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: '1.0'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.5175'
    log: 'True'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '100'
  states: {}
- name: network_tcp_sink_0
  id: network_tcp_sink
  parameters:
    addr: 127.0.0.1
    mode: '1'
    port: '4000'
    type: byte
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 4,0,1,1
    name: ''
    size: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 4,1,1,1
    marker1: '1'
    name: ''
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '80'
    freq0: 433.944e6
    gain0: '80'
    gain_mode0: 'False'
    if_gain0: '80'
    sample_rate: '1000000'
    sync: none
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0_0, '0']
- [digital_gmsk_demod_0, '0', network_tcp_sink_0, '0']
- [rtlsdr_source_0, '0', analog_quadrature_demod_cf_0, '0']
- [rtlsdr_source_0, '0', digital_gmsk_demod_0, '0']
- [rtlsdr_source_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-678-g2ccb54a3
