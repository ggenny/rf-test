options:
  parameters:
    category: Custom
    generate_options: no_gui
    id: top_block
    output_language: python
    run_options: run
  states: {}

blocks:
- name: blocks_complex_to_interleaved_short_0
  id: blocks_complex_to_interleaved_short
  parameters:
    scale_factor: '62768'
    vector_output: 'False'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/ggenny/Develop/rf-test/generated.c16
    type: short
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/ggenny/Develop/rf-test/generated.complex
    repeat: 'False'
    type: complex
  states: {}

connections:
- [blocks_complex_to_interleaved_short_0, '0', blocks_file_sink_0, '0']
- [blocks_file_source_0, '0', blocks_complex_to_interleaved_short_0, '0']

metadata:
  file_format: 1
  grc_version: v3.11.0.0git-678-g2ccb54a3
